# Keil uVision project Window_System.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Window_System
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./Application/: main.c
  group ECUAL
    ./ECUAL/: motor.c motor.h
  group MCAL
    ./MCAL/: DIO.c DIO.h
  group Utilities
    ./Utilities/: bitwise_operation.h tm4c123gh6pm.h types.h
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Heap 10.5.1, CMSIS:CORE 5.6.0, Device:Startup 1.0.1
